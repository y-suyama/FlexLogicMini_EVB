# Repository y-suyama/FlexLogicMini_EVB

File README.md:

# FlexLogicMini Evalution Board
# Revision
## First Version

FTDI Driver Install
Thonny
tearteam

## KiCad design FlexLogicMini_EVB.kicad_pcb

Parts:
C1, C6, C7, C8, C9, C10, C11, C12, C13, C14, C19, C20, C23, C25, C30, C32, C35, C36, C37, C38, C41, C42, C43, C44, C45, C46, C47, C48, C49, C50, C51, C52, C53, C54, C56, C57, C58, C59, C60, C62, C64, C65, C66, C69, C70, C71, C72, C73, C74, C75, C76: 0.1uF; C_0402_1005Metric; MANUFACTURER_PART_NUMBER CL05B104KB54PNC; JLCPCB C307331
C2, C3, C4, C5, C55, C67, C68: 1uF; C_0402_1005Metric; MANUFACTURER_PART_NUMBER CL05A105KA5NQNC; JLCPCB C52923
C15, C16, C21, C22, C24, C40: 10uF; C_0402_1005Metric; MANUFACTURER_PART_NUMBER HGC0402R5106M100NTEJ; JLCPCB C7472949
C17, C18: 0.01uF; C_0402_1005Metric; MANUFACTURER_PART_NUMBER CL05B103KB5NNNC; JLCPCB C15195
C26, C28, C33, C39, C61, C63: 33pF; C_0402_1005Metric; MANUFACTURER_PART_NUMBER 0402CG330J500NT; JLCPCB C1562
C27, C29, C31, C34: 22uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MANUFACTURER_PART_NUMBER HGC0603R5226M100NTHJ; JLCPCB C7432770
D1: LESD5D5-0CT1G; D_SOD-523; MANUFACTURER_PART_NUMBER LESD5D5.0CT1G-ES; JLCPCB C5199159
D2: XL-1005UBC; LED_0402_1005Metric_Pad0.77x0.64mm_HandSolder; MANUFACTURER_PART_NUMBER XL-1005UBC; JLCPCB C22355736
IC1: SL2.1s; SSOP-16_L4.6-W2.6-P0.53-LS4.0-BL; MANUFACTURER_PART_NUMBER SL2.1S; JLCPCB C2684433
IC2: MT9700; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR; MANUFACTURER_PART_NUMBER MT9700; JLCPCB C42441843
IC3: MTS4P; MANUFACTURER_PART_NUMBER MTS4P; JLCPCB C19284877
IC4: LCMXO2-1200HC-4SG32I; QFN50P500X500X60-33N_handsolder; Manufacturer_Part_Number LCMXO2-1200HC-4SG32I; Mouser Part Number 842-MXO21200HC4SG32I
IC5: W25Q16JVUXIQ; SON50P300X200X60-9N_handsolder; MANUFACTURER_PART_NUMBER W25Q16JVUXIQ; JLCPCB C2843335
J1: GT-USB-7010ASV; USB-C-SMD_G-SWITCH_GT-USB-7010ASV; MANUFACTURER_PART_NUMBER GT-USB-7010ASV; JLCPCB C2988369
J2, J3, J4, J5: WJ126V-5.0-2P; MANUFACTURER_PART_NUMBER WJ126V-5.0-2P; JLCPCB C8404
J6, J7, J8, J9, J10: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J11: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J12, J13: 1.0-3PWB; MANUFACTURER_PART_NUMBER 1.0-3PWB; JLCPCB C2905005
L1, L2, L4, L5, L6, L7, L8: HCB1005KF-121T20; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder; MANUFACTURER_PART_NUMBER HCB1005KF-121T20; JLCPCB C141722
L3: 1.5uH; FTC252012S1R5MBCA; MANUFACTURER_PART_NUMBER FTC252012S1R5MBCA; JLCPCB C5832371
R1, R2, R3, R4, R5, R6, R7, R8: 1M; R_0402_1005Metric; MANUFACTURER_PART_NUMBER 0402WGF1004TCE; JLCPCB C26083
R9, R10, R11, R12, R13, R14, R15, R16: 220; R_0402_1005Metric; MANUFACTURER_PART_NUMBER 0402WGF2200TCE; JLCPCB C25091
R17, R18: 5.1k; R_0402_1005Metric; MANUFACTURER_PART_NUMBER 0402WGF5101TCE; JLCPCB C25905
R19, R22, R23, R25, R26, R32, R34, R37, R38, R39, R47: 10k; R_0402_1005Metric; MANUFACTURER_PART_NUMBER 0402WGF1002TCE; JLCPCB C25744
R20: 3.6k; R_0402_1005Metric; MANUFACTURER_PART_NUMBER SCR0402J3K6; JLCPCB C3017490
R21, R24, R30, R31, R36, R50, R51: 2.2k; R_0402_1005Metric; MANUFACTURER_PART_NUMBER 0402WGF2201TCE; JLCPCB C25879
R27, R33, R35, R55: 4.7k; R_0402_1005Metric; MANUFACTURER_PART_NUMBER 0402WGF4701TCE; JLCPCB C25900
R28: 22k; R_0402_1005Metric; MANUFACTURER_PART_NUMBER 0402WGF2202TCE; JLCPCB C25768
R29: 100k; R_0402_1005Metric; MANUFACTURER_PART_NUMBER 0402WGF1003TCE; JLCPCB C25741
R40, R45, R46, R48, R49: 33; R_0402_1005Metric; MANUFACTURER_PART_NUMBER 0402WGF330JTCE; JLCPCB C25105
R41: 12k; R_0402_1005Metric; MANUFACTURER_PART_NUMBER HGC0402R5106M100NTEJ; JLCPCB C25752
R42: 10k; R_0402_1005Metric; MANUFACTURER_PART_NUMBER 0402WGF1002TCE; JLCPCB C25744; not fitted
R43, R44, R53, R54: 100; R_0402_1005Metric; MANUFACTURER_PART_NUMBER 0402WGF1000TCE; JLCPCB C25076
R52: 1k; R_0402_1005Metric; MANUFACTURER_PART_NUMBER 0402WGF1001TCE; JLCPCB C11702
RN1, RN3: 30Ω; RES-ARRAY-SMD_0402-4P-L1.0-W1.0-BL; Manufacturer Part 2D02WGJ0300TCE; LCSC C425336
RN2: 10kΩ; RES-ARRAY-SMD_0804-8P-L2.0-W1.0-BL; Manufacturer Part FRA044RJ103 TS; LCSC C52175177
S1: SKRPACE010; SW_SKRPACE010; MANUFACTURER_PART_NUMBER SKRPACE010; JLCPCB C139797
SW1: DSWB02LHGETB; MANUFACTURER_PART_NUMBER DSWB02LHGETB; JLCPCB C964136
TP1, TP2: TestPoint; TestPoint_Pad_D1.0mm
U1, U2: ADS1115IDGSR; DGS0010A_M; MANUFACTURER_PART_NUMBER ADS1115IDGSR; JLCPCB C37593
U3, U6, U8: RQ12000160; CRYSTAL-SMD_4P-L2.5-W2.0-BL; MANUFACTURER_PART_NUMBER RQ12000160; JLCPCB C2929403
U4: RT5752BHGJ5; TSOT-23-5; MANUFACTURER_PART_NUMBER RT5752BHGJ5; JLCPCB C3003186
U5: 93LC56BT-I; MANUFACTURER_PART_NUMBER 93LC56BT-I; JLCPCB C190271
U7: FT2232HL; LQFP-64_10x10mm_P0.5mm; MANUFACTURER_PART_NUMBER FT2232HL; JLCPCB C27882
U9: TLV803SDBZR; DBZ0003A_N; MANUFACTURER_PART_NUMBER TLV803SDBZR; JLCPCB C132016
U10: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm_handsolder; MANUFACTURER_PART_NUMBER RP2040; JLCPCB C2040

Connections:
+1.1V_MCU: C64.1, C65.1, C67.2, U10.23 (DVDD), U10.45 (VREG_VOUT), U10.50 (DVDD)
+3.3V: C31.1, C34.1, L3.2, L4.1, L5.1, L6.1, L7.1, L8.1, R29.2
+3.3V_ADC: C17.1, C18.1, C19.1, C20.1, C30.1, C42.1, IC3.3 (VDD), L7.2, R1.1, R3.1, R5.1, R7.1, R23.1, U1.8 (VDD), U2.8 (VDD)
+3.3V_A_FT2232H: C41.1, C53.1, C54.1, L6.2, U7.4 (VPHY), U7.9 (VPLL)
+3.3V_D: C25.1, C35.1, C36.1, C37.1, C38.1, C44.1, C47.1, C50.1, C52.1, C55.2, C57.1, C68.2, C69.1, C70.1, C71.1, C72.1, C73.1, C74.1, C75.1, C76.1, IC4.2 (VCC_1), IC4.6 (VCCIO3), IC4.7 (VCCIO2_1), IC4.15 (VCCIO2_2), IC4.18 (VCC_2), IC4.19 (VCCIO1), IC4.24 (VCCIO0_1), IC4.31 (VCCIO0_2), IC5.8 (VCC), J11.2, L4.2, R21.1, R24.1, R25.1, R26.1, R31.1, R33.1, R35.1, R37.1, R39.1, R42.1, R47.1, R50.1, R51.1, U10.1 (IOVDD), U10.10 (IOVDD), U10.22 (IOVDD), U10.33 (IOVDD), U10.42 (IOVDD), U10.43 (ADC_AVDD), U10.44 (VREG_IN), U10.48 (USB_VDD), U10.49 (IOVDD); also elsewhere on the board
+3.3V_EXT: C1.1, C43.1, J8.3, L8.2
+3.3V_FT2232H: C32.1, C49.1, C56.1, C58.1, C59.1, C60.1, L5.2, R32.1, R34.1, R38.1, R55.1, RN2.5, RN2.6, RN2.7, RN2.8, U5.6 (VCC), U7.20 (VCCIO), U7.31 (VCCIO), U7.42 (VCCIO), U7.50 (VREGIN), U7.56 (VCCIO)
/D_N: IC1.5 (UDM), J1.A7 (DN1), J1.B7 (DN2)
/D_P: IC1.6 (UDP), J1.A6 (DP1), J1.B6 (DP2)
/FT2232H_N: RN1.3, U7.7 (DM)
/FT2232H_P: RN1.4, U7.8 (DP)
/JTAG Select/TCK_FT2232H: U7.16 (ADBUS0); also elsewhere on the board
/JTAG Select/TDI_FT2232H: U7.17 (ADBUS1); also elsewhere on the board
/JTAG Select/TDO_FT2232H: U7.18 (ADBUS2); also elsewhere on the board
/JTAG Select/TMS_FT2232H: U7.19 (ADBUS3); also elsewhere on the board
/RP2040_N: RN3.3, U10.46 (USB_DM)
/RP2040_P: RN3.4, U10.47 (USB_DP)
CLK12M: C39.1, IC4.4 (PL9A), U6.3 (OSC2), U7.3 (OSCO)
CTS_N_PIN: J10.4, RN2.1, U7.41 (BDBUS3)
EVBDET_N: J8.4, U10.38 (GPIO26_ADC0)
FPGA_IO1: IC4.12 (PB9B), J9.1
FPGA_IO2: IC4.13 (PB11A), J9.2
FPGA_IO3: IC4.14 (PB11B), J9.3
FPGA_IO4: IC4.20 (PR5D), J9.4
FPGA_IO5: IC4.21 (PR5C), J9.5
GND: C1.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.1, C29.2, C30.2, C31.2, C32.2, C33.1, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.1, C56.2, C57.2, C58.2, C59.2, C60.2, C61.1, C62.2, C63.2, C64.2, C65.2, C66.2, C67.1, C68.1, C69.2, C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, C76.2, D1.2 (A2), D2.1 (K), IC1.8 (VSS), IC2.2 (GND), IC3.2 (GND), IC3.5 (EP), IC4.3 (GND_1), IC4.22 (GND_2)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; also elsewhere on the board
I2CSCL_ADC: IC3.1 (SCL), J8.1, R51.2, U1.10 (SCL), U2.10 (SCL), U10.5 (GPIO3)
I2CSCL_OLED: J11.3, R24.2, U10.3 (GPIO1)
I2CSDA_ADC: IC3.4 (SDA), J8.2, R50.2, U1.9 (SDA), U2.9 (SDA), U10.4 (GPIO2)
I2CSDA_OLED: J11.4, R21.2, U10.2 (GPIO0)
IRQ_FPGA: IC4.5 (PL9B), R27.1, U10.29 (GPIO18)
JTAG_SEL0: R55.2, SW1.2; also elsewhere on the board
LogicAna1: J6.1, U10.15 (GPIO12)
LogicAna2: J6.2, U10.16 (GPIO13)
LogicAna3: J6.3, U10.17 (GPIO14)
LogicAna4: J6.4, U10.18 (GPIO15)
unnamed: C14.1, D1.1 (A1), J1.A4B9 (VBUS), J1.B4A9 (VBUS), L1.1, R19.1
unnamed: D2.2 (A), R19.2
unnamed: C22.1, IC1.10 (VDD18)
unnamed: C21.1, IC1.9 (VDD33)
unnamed: C28.2, IC1.12 (XIN), U3.1 (OSC)
unnamed: C26.1, IC1.11 (XOUT), U3.3 (OSC2)
unnamed: C15.1, IC2.4 (EN), IC2.5 (VIN), L1.2
unnamed: IC2.3 (SET), R20.1
unnamed: IC4.16 (PB20C), R26.2
unnamed: IC4.26 (PT15C), R33.2
unnamed: IC4.25 (PT15D), R35.2
unnamed: J1.A5 (CC1), R17.1
unnamed: J1.B5 (CC2), R18.1
unnamed: J2.1, R2.1, R10.1
unnamed: J2.2, R1.2, R9.1
unnamed: J3.1, R4.1, R12.1
unnamed: J3.2, R3.2, R11.1
unnamed: J4.1, R6.1, R14.1
unnamed: J4.2, R5.2, R13.1
unnamed: J5.1, R8.1, R16.1
unnamed: J5.2, R7.2, R15.1
unnamed: J12.1, R43.1
unnamed: J12.3, R44.1
unnamed: J13.1, R53.2
unnamed: J13.3, R54.2
unnamed: R48.2, S1.1, S1.2
unnamed: R52.1, SW1.1
unnamed: R22.1, U1.1 (ADDR)
unnamed: C4.2, C10.1, R13.2, U1.4 (AIN0)
unnamed: C4.1, C11.1, R14.2, U1.5 (AIN1)
unnamed: C5.2, C12.1, R15.2, U1.6 (AIN2)
unnamed: C5.1, C13.1, R16.2, U1.7 (AIN3)
unnamed: R23.2, U2.1 (ADDR)
unnamed: C2.2, C6.1, R9.2, U2.4 (AIN0)
unnamed: C2.1, C7.1, R10.2, U2.5 (AIN1)
unnamed: C3.2, C8.1, R11.2, U2.6 (AIN2)
unnamed: C3.1, C9.1, R12.2, U2.7 (AIN3)
unnamed: C27.1, C29.1, L2.2, U4.1 (EN), U4.4 (VIN)
unnamed: R28.2, R29.1, U4.5 (FB)
unnamed: L3.1, U4.3 (SW)
unnamed: R40.1, U5.4 (CLK)
unnamed: R38.2, U5.5 (CS), U7.63 (EECS)
unnamed: R34.2, R36.2, U5.3 (DI), U7.61 (EEDATA)
unnamed: R32.2, R36.1, U5.1 (DO)
unnamed: C33.2, U6.1 (OSC), U7.2 (OSCI)
unnamed: R40.2, U7.62 (EECLK)
unnamed: R41.1, U7.6 (REF)
unnamed: C63.1, R45.1, U8.3 (OSC2)
unnamed: TP1.1 (1_1), U10.8 (GPIO6)
unnamed: R53.1, U10.11 (GPIO8)
unnamed: R54.1, U10.12 (GPIO9)
unnamed: TP2.1 (1_1), U10.30 (GPIO19)
unnamed: R49.1, U10.34 (GPIO22)
unnamed: R46.2, U10.52 (QSPI_SCLK)
unnamed: R43.2, U10.24 (SWCLK)
unnamed: R44.2, U10.25 (SWD)
unnamed: C61.2, U8.1 (OSC), U10.20 (XIN)
unnamed: R45.2, U10.21 (XOUT)
QSPI_SCLK: IC5.6 (CLK), R46.1
QSPI_SD0: IC5.5 (DI_(IO0)), U10.53 (QSPI_SD0)
QSPI_SD1: IC5.2 (DO_(IO1)), U10.55 (QSPI_SD1)
QSPI_SD2: IC5.3 (~WP_(IO2)), U10.54 (QSPI_SD2)
QSPI_SD3: IC5.7 (~HOLD_OR_RESET_(IO3)), U10.51 (QSPI_SD3)
QSPI_SS: IC5.1 (~CS), R42.2, R52.2, U10.56 (QSPI_SS)
RESET_N: C66.1, IC4.11 (PB9A), R47.2, R48.1, U7.14 (~RESET), U9.2 (RESET_N), U10.26 (RUN)
RTS_N_PIN: J10.3, RN2.2, U7.40 (BDBUS2)
RXD_PIN: J10.2, RN2.3, U7.39 (BDBUS1)
SPI0_CLK: IC4.9 (PB6C), R49.2
SPI0_CS_N: IC4.27 (PT12D), R39.2, U10.32 (GPIO21)
SPI0_MISO: IC4.10 (PB6D), R25.2, U10.31 (GPIO20)
SPI0_MOSI: IC4.17 (PB20D), R37.2, U10.35 (GPIO23)
TCK_FPGA: IC4.30 (PT11C), R30.1; also elsewhere on the board
TCK/SWCLK_PIN: J7.1; also elsewhere on the board
TDI_FPGA: IC4.32 (PT10D); also elsewhere on the board
TDI/SWDIO_PIN: J7.3; also elsewhere on the board
TDO_FPGA: IC4.1 (PT10C); also elsewhere on the board
TDO_PIN: J7.4; also elsewhere on the board
TMS_FPGA: IC4.29 (PT11D), R31.2; also elsewhere on the board
TMS_PIN: J7.2; also elsewhere on the board
TXD_PIN: J10.1, RN2.4, U7.38 (BDBUS0)
USB_FT2232H+: IC1.2 (DP2), RN1.1
USB_FT2232H-: IC1.1 (DM2), RN1.2
USB_MCU+: IC1.4 (DP1), RN3.1
USB_MCU-: IC1.3 (DM1), RN3.2
VBUS: C16.1, C23.1, C24.1, C62.1, IC1.7 (VDD5), IC2.1 (VOUT), L2.1, U9.3 (VDD)
VCORE_FT2232H: C40.1, C45.1, C46.1, C48.1, C51.1, U7.12 (VCORE), U7.37 (VCORE), U7.49 (VREGOUT), U7.64 (VCORE)

Notes on the sheet:
DIP SW
UART Pinheader
min:3.24V typ:3.33V max:3.42V 0.647Amax
USB2.0 HUB
BOOTSEL
Power on Reset
DBGP_SWCLK GND DBGP_SWDIO
Slave Address 0x49
SWD Debug
BOOTSEL(RP2040)
Global CLK
Current Limit 1.9A(Rset=3.6kΩ)
typeC
CPU(RP2040)
CPLD MachXO2 LCMXO2-1200HC-4SG32I
JTAG Pinheader
ThermoCouple ADC
Analyzer Pinheader
USB to UART/JTAG/SPI/I2C(FT2232HL)
JTAGSEL0(ASW)
VBR=5.6Vmin
60mA
JTAG
To FPGA
Blue LED
12MHz
Disable Flash Boot (forces USB boot)
OLED Interface
DC/DC 5V → 3.3V
Ron=100mΩmax, Reverse Blocking
Slave Address 0x48
CPLD Pinheader
EEPROM(FT2232H Mode Selection) 128 x 16bit
シングルエンドCLKは必ずT側に接続
215mA
Slave Address 0x41
J3とJ4の間に配置 部品面で一点アース Via禁止
10mA
External Signal Pinheader
SWD Debug Probe(PIO0)

Parts:
C77: 0.1uF; C_0402_1005Metric; MANUFACTURER_PART_NUMBER CL05B104KB54PNC; JLCPCB C307331
U11: TMUX1574DYYR; SOT-23-THIN-16_DYY_TEX; MANUFACTURER_PART_NUMBER TMUX1574DYYR; JLCPCB C1855769

Connections:
+3.3V_D: C77.1, U11.16 (VDD); also elsewhere on the board
/JTAG Select/TCK_FT2232H: U11.4 (D1); also elsewhere on the board
/JTAG Select/TDI_FT2232H: U11.7 (D2); also elsewhere on the board
/JTAG Select/TDO_FT2232H: U11.9 (D3); also elsewhere on the board
/JTAG Select/TMS_FT2232H: U11.12 (D4); also elsewhere on the board
GND: C77.2, U11.8 (GND), U11.15 (*EN); also elsewhere on the board
JTAG_SEL0: U11.1 (SEL); also elsewhere on the board
TCK_FPGA: U11.3 (S1B); also elsewhere on the board
TCK/SWCLK_PIN: U11.2 (S1A); also elsewhere on the board
TDI_FPGA: U11.6 (S2B); also elsewhere on the board
TDI/SWDIO_PIN: U11.5 (S2A); also elsewhere on the board
TDO_FPGA: U11.10 (D3B); also elsewhere on the board
TDO_PIN: U11.11 (D3A); also elsewhere on the board
TMS_FPGA: U11.13 (S4B); also elsewhere on the board
TMS_PIN: U11.14 (S4A); also elsewhere on the board

Notes on the sheet:
SEL, *EN Weak pull down:6MΩ(typ)
JTAG Select
1(default)
CPLD
JTAG_SEL(DPSW 2)
接続先
PIN Header
Charge Injection:3.5pC(typ)

Board: 8 copper layers, 50.0 x 50.0 mm, 178 parts (110 on the bottom side), 122 nets.

File production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C10, C11, C12, C13, C14, C19, C20, C23, C25, C30, C32, C35, C36, C37, C38, C41, C42, C43, C44, C45, C46, C47, C48, C49, C50, C51, C52, C53, C54, C56, C57, C58, C59, C6, C60, C62, C64, C65, C66, C69, C7, C70, C71, C72, C73, C74, C75, C76, C77, C8, C9",0402,52,0.1uF,
"C15, C16, C21, C22, C24, C40",0402,6,10uF,
"C17, C18",0402,2,0.01uF,
"C2, C3, C4, C5, C55, C67, C68",0402,7,1uF,
"C26, C28, C33, C39, C61, C63",0402,6,33pF,
"C27, C29, C31, C34",0603,4,22uF,
D1,D_SOD-523,1,LESD5D5-0CT1G,
D2,0402,1,XL-1005UBC,
IC1,SSOP-16_L4.6-W2.6-P0.53-LS4.0-BL,1,SL2.1s,
IC2,SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR,1,MT9700,
IC3,MTS4P,1,MTS4P,
IC4,QFN50P500X500X60-33N_handsolder,1,LCMXO2-1200HC-4SG32I,https://www.lcsc.com/product-detail/Programmable-Logic-Devic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
IC5,SON50P300X200X60-9N_handsolder,1,W25Q16JVUXIQ,
J1,USB-C-SMD_G-SWITCH_GT-USB-7010ASV,1,GT-USB-7010ASV,
"J10, J6, J7, J8, J9",PinHeader_2x03_P2.54mm_Vertical,5,Conn_02x03_Odd_Even,
J11,PinHeader_1x04_P2.54mm_Vertical,1,Conn_01x04,
"J12, J13",1.0-3PWB,2,1.0-3PWB,
"J2, J3, J4, J5",WJ126V-5.0-2P,4,WJ126V-5.0-2P,
"L1, L2, L4, L5, L6, L7, L8",0402,7,HCB1005KF-121T20,
L3,FTC252012S1R5MBCA,1,1.5uH,
"R1, R2, R3, R4, R5, R6, R7, R8",0402,8,1M,
"R10, R11, R12, R13, R14, R15, R16, R9",0402,8,220,
"R17, R18",0402,2,5.1k,
"R19, R22, R23, R25, R26, R32, R34, R37, R38, R39, R47",0402,11,10k,
R20,0603,1,3.6k,
"R21, R24, R30, R31, R36, R50, R51",0402,7,2.2k,
"R27, R33, R35, R55",0402,4,4.7k,
R28,0402,1,22k,
R29,0402,1,100k,
"R40, R45, R46, R48, R49",0402,5,33,
R41,0402,1,12k,
"R43, R44, R53, R54",0402,4,100,
R52,0402,1,1k,
"RN1, RN3",RES-ARRAY-SMD_0402-4P-L1.0-W1.0-BL,2,30Ω,C425336
RN2,RES-ARRAY-SMD_0804-8P-L2.0-W1.0-BL,1,10kΩ,C52175177
S1,SW_SKRPACE010,1,SKRPACE010,
SW1,DSWB02LHGETB,1,DSWB02LHGETB,
"TP1, TP2",TestPoint_Pad_D1.0mm,2,TestPoint,
"U1, U2",DGS0010A_M,2,ADS1115IDGSR,
U10,QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm_handsolder,1,RP2040,
U11,SOT-23-THIN-16_DYY_TEX,1,TMUX1574DYYR,https://www.lcsc.com/product-detail/Analog-Switches-Multiple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
"U3, U6, U8",CRYSTAL-SMD_4P-L2.5-W2.0-BL,3,RQ12000160,
U4,TSOT-23-5,1,RT5752BHGJ5,
U5,93LC56BT-I,1,93LC56BT-I,
U7,LQFP-64_10x10mm_P0.5mm,1,FT2232HL,
U9,DBZ0003A_N,1,TLV803SDBZR,

## Commit log (part)

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2025-09-23 Initial commit: upload FlexLogicMini_EVB environment
2025-11-28 Final commit
